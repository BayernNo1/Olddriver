<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Debug</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>Release</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <group>
    <name>Project_Settings</name>
    <group>
      <name>Link</name>
      <file>
        <name>$PROJ_DIR$\src\Project_Settings\Link\Pflash.icf</name>
      </file>
      <file>
        <name>$PROJ_DIR$\src\Project_Settings\Link\Ram.icf</name>
      </file>
    </group>
    <group>
      <name>Startup_Code</name>
      <file>
        <name>$PROJ_DIR$\src\Project_Settings\Startup_Code\crt0.s</name>
      </file>
      <file>
        <name>$PROJ_DIR$\src\Project_Settings\Startup_Code\start.c</name>
      </file>
    </group>
  </group>
  <group>
    <name>Sources</name>
    <group>
      <name>modified</name>
      <group>
        <name>C</name>
        <file>
          <name>$PROJ_DIR$\src\Sources\C\isr.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\src\Sources\C\main.c</name>
        </file>
      </group>
      <group>
        <name>H</name>
      </group>
    </group>
    <group>
      <name>original</name>
      <group>
        <name>C</name>
        <file>
          <name>$PROJ_DIR$\src\Sources\C\adc.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\src\Sources\C\CCD.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\src\Sources\C\common.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\src\Sources\C\filter.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\src\Sources\C\findline.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\src\Sources\C\Flash.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\src\Sources\C\Ftm.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\src\Sources\C\gpio.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\src\Sources\C\keyscan.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\src\Sources\C\oled.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\src\Sources\C\Pit.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\src\Sources\C\sysinit.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\src\Sources\C\uart.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\src\Sources\C\vectors.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\src\Sources\C\wdog.c</name>
        </file>
      </group>
      <group>
        <name>H</name>
        <file>
          <name>$PROJ_DIR$\src\Sources\H\adc.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\src\Sources\H\ccd.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\src\Sources\H\common.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\src\Sources\H\filter.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\src\Sources\H\findline.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\src\Sources\H\Flash.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\src\Sources\H\Ftm.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\src\Sources\H\gpio.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\src\Sources\H\includes.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\src\Sources\H\keyscan.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\src\Sources\H\MK60N512VMD100.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\src\Sources\H\oled.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\src\Sources\H\Pit.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\src\Sources\H\sysinit.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\src\Sources\H\uart.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\src\Sources\H\vectors.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\src\Sources\H\wdog.h</name>
        </file>
      </group>
    </group>
  </group>
</project>



# IAR project old_driver.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK60DN512xxx10 Freescale MK60DN512xxx10
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCIncludePath2: src\Sources\H; src\Sources\H\Component_H; src\Sources\H\Frame_H; src\Sources\H\Function_H
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: old_driver.srec
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkIcfFile: src\Project_Settings\Link\Pflash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  group Project_Settings/Link
    src/Project_Settings/Link/: Pflash.icf Ram.icf
  group Project_Settings/Startup_Code
    src/Project_Settings/Startup_Code/: crt0.s start.c
  group Sources/modified/C
    src/Sources/C/: isr.c main.c
  group Sources/original/C
    src/Sources/C/: adc.c CCD.c common.c filter.c Flash.c Ftm.c gpio.c keyscan.c oled.c Pit.c sysinit.c uart.c vectors.c wdog.c
  group Sources/original/H
    src/Sources/H/: adc.h ccd.h common.h filter.h Flash.h Ftm.h gpio.h includes.h keyscan.h MK60N512VMD100.h oled.h Pit.h sysinit.h uart.h vectors.h wdog.h
